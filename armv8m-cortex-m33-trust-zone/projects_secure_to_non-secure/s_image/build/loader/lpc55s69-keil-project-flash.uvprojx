# Keil uVision project lpc55s69-keil-project-flash.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: LPC55S69JBD100:cm33_core0 NXP
  pack: NXP.LPC55S69_DFP.25.03.00
  cpu: IRAM(0x10000000,0x09d800) IRAM2(0x20000000,0x040000) IROM(0x03000000,0x020000) IROM2(0x13000000,0x020000) XRAM(0x20040000,0x4000) XRAM2(0x30040000,0x4000) XRAM3(0x04000000,0x8000) XROM(0x00000000,0x09d800) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: example_01_s.elf
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT1: ROM 0x0 size 0x9d800
  memory RVCT4: ROM 0x3000000 size 0x20000
  memory RVCT5: ROM 0x13000000 size 0x20000
  memory RVCT6: RAM 0x20040000 size 0x4000
  memory RVCT7: RAM 0x30040000 size 0x4000
  memory RVCT8: RAM 0x4000000 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x9d800
  memory RVCT10: RAM 0x20000000 size 0x40000
